Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-09-06T12:49:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Sep 06 12:49:57 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{12D564B9-8A7B-4094-9C88-16AFF6881E4F}\ifc * Database version: 5507 * Database creation date: Fri Sep 06 12:49:57 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Sep 06 12:49:57 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Sep 06 12:49:57 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 04790200 Shower rail, 04790200:04790200 Shower rail:488550
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - Diameter: 22 mm; NominalDepth: 103.406 mm; NominalHeight: 1010 mm; NominalWidth: 67.4 mm; Pipe Length: 970 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 04790200; ConvergoRefNr: 0087-1909-0102-FI; ManufacterURL: http://www.hansa.com/; ManufacturerName: Hansa; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_20_97_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 24/07/2019
Type - Green Building Properties(Type) - Customs Code: 74182000; EAN Number: 4057304009013
Type - Identity Data(Type) - Catalog Drawing URL: http://static.hansa.com/catdrw/04790200; FDV Document URL: http://www.hansa.com/datasheet/04790200/en/fdv; Group: Hand showers and shower sets; Manufacturer: Hansa; Market: DEU;INT;AUT;BEL;ITA;NLD; Model: 04790200 Shower rail; Name_en: 04790200 Shower rail; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 1031 x 156 x 74; Package Weight: 0.869 kg; Product Code: 04790200; Product Datasheet: http://www.hansa.com/datasheet/04790200/en; Product Family: HANSAACTIVEJET; Product Image URL: http://static.hansa.com/image/04790200; Product URL: http://static.hansa.com/04790200; Type Name: 04790200 Shower rail
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Can be shortened; Installation and Maintenance: http://static.hansa.com/manual/04790200; Installation Type: Wall mounted; Max. Hot Water Supply: 65 kg/K/s3; Mechanical Parts: FixingSet; Shower Parts: Shower rail;Wall distance adjustable;Shower bracket adjustable; Spare Parts: http://static.hansa.com/sp/04790200
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Hansa; Category: Bathroom, shower; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 04790200; Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 04790200; Name: 04790200 Shower rail; ReplacementCost: n/a; Shape: Sculptured; Size: 65x105x1010 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 04790200; Manufacturer: Hansa
Pset_DistributionFlowElementCommon - Reference: 04790200 Shower rail
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.179373 m2; Volume: 0.00703228 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 04790200: 04790200 Shower rail; Family and Type: 04790200: 04790200 Shower rail; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 04790200: 04790200 Shower rail; Type Id: 04790200: 04790200 Shower rail; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
